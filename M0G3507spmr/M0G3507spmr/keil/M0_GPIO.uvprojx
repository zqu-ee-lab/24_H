# Keil uVision project M0_GPIO.uvprojx, settings and files
target Target 1 (6210000::V6.21::ARMCLANG)
  device: MSPM0G3507 Texas Instruments
  pack: TexasInstruments.MSPM0G1X0X_G3X0X_DFP.1.3.0
  cpu: IRAM(0x20000000,0x00008000) IRAM2(0x20100000,0x00008000) IROM(0x00000000,0x00020000) IROM2(0x00400000,0x00020000) XRAM(0x20200000,0x00008000) XRAM2(0x20300000,0x00008000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: M0_GPIO +hex
  c flags: Optim=3 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: __MSPM0G3507__
  c include: .\Include;..;..\MCU_Drives;.\Hardware;..\dev_lib;..\APP
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT5: ROM 0x400000 size 0x20000
  memory RVCT7: RAM 0x20300000 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x8000
  memory RVCT10: RAM 0x20200000 size 0x8000
  scatter file: .\mspm0g3507.sct
  group APP
    ../APP/: main.c my_task.c
    ../: untitled.syscfg
    ./: startup_mspm0g350x_uvision.s
  group MCU_Drives
    ../MCU_Drives/: ti_msp_dl_config.c ti_msp_dl_config.h
  group Driverlib
    ../: driverlib.a
  group Hardware
    ./Hardware/: delay.c delay.h EXTI.c EXTI.h LED.c LED.h OLED.c OLED.h OLED_Font.h Servo.c Servo.h TIME.c TIME.h UART.c UART.h OLED_Font.c oled_buffer.c oled_draw.c
  group Dev
    ../dev_lib/: DEV_I2C.c buffer.c DEV_Grayscale.c PID.c Stepper.c DEV_CAR.c UI_.c
